# Keil uVision project atk_f103.uvprojx, settings and files
target E_BIKE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --no-multibyte-chars --diag_suppress=68 --diag_suppress=111 --diag_suppress=188 --diag_suppress=223 --diag_suppress=546  --diag_suppress=1295
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\BSP;..\..\Drivers;..\..\User;..\..\Middlewares\FreeRTOS\include;..\..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM3;..\..\Middlewares\LVGL\GUI\lvgl\src;..\..\Middlewares\LVGL\GUI\lvgl\examples\porting;..\..\Middlewares\LVGL\GUI_APP;..\..\Middlewares\LVGL\GUI\lvgl
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Include/: stm32f103xe.h
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../../User/: main.c stm32f1xx_it.c stm32f1xx_hal_conf.h freertos_demo.c task_freq.c task_out_rs485.c task_out_light.c task_adc.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../../Middlewares/FreeRTOS/include/: FreeRTOSConfig.h
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_exti.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_wwdg.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_i2s.c stm32f1xx_hal_spi.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_sram.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_pwr.c
  group Drivers/BSP
    ../../Drivers/BSP/: mpu6050.c mpu6050.h myiic.c adc.c timer_pwm.c st7789.c key.c rs485.c stmflash.c pwr.c
  group Middlewares\FreeRTOS
    ../../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares\FreeRTOS\portable
    ../../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../../Middlewares/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group Middlewares\LVGL\examples
    ../../Middlewares/LVGL/GUI/lvgl/examples/porting/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c
  group Middlewares\LVGL\src\core
    ../../Middlewares/LVGL/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group Middlewares\LVGL\src\draw
    ../../Middlewares/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../Middlewares/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
  group Middlewares\LVGL\src\extra
    ../../Middlewares/LVGL/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../Middlewares/LVGL/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../Middlewares/LVGL/GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../../Middlewares/LVGL/GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../../Middlewares/LVGL/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../../Middlewares/LVGL/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../../Middlewares/LVGL/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../Middlewares/LVGL/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ../../Middlewares/LVGL/GUI/lvgl/src/extra/: lv_extra.c
  group Middlewares\LVGL\src\gpu
    ../../Middlewares/LVGL/GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../../Middlewares/LVGL/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
  group Middlewares\LVGL\mix
    ../../Middlewares/LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../../Middlewares/LVGL/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../Middlewares/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Middlewares\LVGL\GUI_APP
    ../../Middlewares/LVGL/GUI_APP/: my_gui.c
    ../../Middlewares/LVGL/GUI/lvgl/: lv_conf.h
  group Middlewares\LVGL\GUI_FONT_IMG
    ../../Middlewares/LVGL/GUI_APP/GUI_FONT_IMG/: my_font_16.c my_num_35.c bl_1.c bl_4.c my_num_24.c
    ../../../../6.24/E_BIKE(FreeRTOS+LVGL)_RET6/Middlewares/LVGL/GUI_APP/GUI_FONT_IMG/: bl_0.c
